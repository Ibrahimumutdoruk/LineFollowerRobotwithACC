# Keil uVision project LineFollower.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LineFollower
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: PROJECT_NOTES.txt main.c OLED DRIVER.c OLED DRIVER.h GPIO_DRIVER.c GPIO_DRIVER.h SYSTICK_DRIVER.c SYSTICK_DRIVER.h TIMER1_DRIVER.c TIMER1_DRIVER.h SYSTEM_CLOCK.c SYSTEM_CLOCK.h I2C_DRIVER.c I2C_DRIVER.h SPI_DRIVER.c SPI_DRIVER.h MOTOR_DRIVER.c MOTOR_DRIVER.h ADC_DRIVER.c ADC_DRIVER.h PID.c PID.h Buzzer.c Buzzer.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, Device:GPIO 1.3, Device:Startup 1.0.0
